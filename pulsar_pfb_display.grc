<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pulsar_pfb_display</value></param>
<param><key>author</key><value>Marcus Leech</value></param>
<param><key>description</key><value>A pulsar monitoring program</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Pulsar monitor using PFB filterbank</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bwlim</value></param>
<param><key>value</key><value>samp_rate/2.2 if bw &gt; 100e6 else bw/2.2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dispfilter</value></param>
<param><key>value</key><value>pulsar_pfb_helper.compute_dispfilter(dm,1.0,samp_rate,the_freq)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>drate</value></param>
<param><key>value</key><value>if_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>if_rate</value></param>
<param><key>value</key><value>20e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ldisp</value></param>
<param><key>value</key><value>len(dispfilter)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log_status</value></param>
<param><key>value</key><value>pulsar_pfb_helper.log(profile_prober,prefix,longitude,0,the_freq,srate,decln,tstart,tend,xmlport)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>log_status_0</value></param>
<param><key>value</key><value>pulsar_pfb_helper.log(tp_prober,prefix,longitude,1,the_freq,srate,decln,tstart,tend,xmlport)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nrfi</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>profile_prober</value></param>
<param><key>block_id</key><value>profile_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>[0.0]*psize</value></param>
<param><key>poll_rate</key><value>0.2</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>pulsar_folded_vector</value></param>
<param><key>block_id</key><value>pulsar_sink</value></param>
<param><key>function_name</key><value>get_ovect</value></param>
<param><key>value</key><value>[0.0]*(psize*sfold)</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>srate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>smtime</value></param>
<param><key>value</key><value>"%7.3f" % (pulsar_pfb_helper.smear_time(dm,samp_rate,freq)*1000.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>soundfile</value></param>
<param><key>value</key><value>"/dev/null"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>the_freq</value></param>
<param><key>value</key><value>freq if skyfreq &lt; 0.0 else skyfreq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tit</value></param>
<param><key>value</key><value>"Pulse profile @ %7.3fMHz" % (freq/1.0e6)</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>tp_prober</value></param>
<param><key>block_id</key><value>tp_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0.0</value></param>
<param><key>poll_rate</key><value>0.5</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>value</key><value>"%8.4fMHz" % (freq/1.0e6)</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0</value></param>
<param><key>value</key><value>dm</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>DM</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0_0</value></param>
<param><key>value</key><value>prate</value></param>
<param><key>gui_hint</key><value>0,2,1,1</value></param>
<param><key>label</key><value>Pulse Rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0_0_0</value></param>
<param><key>value</key><value>decln</value></param>
<param><key>gui_hint</key><value>0,3,1,1</value></param>
<param><key>label</key><value>Declination</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0_0_1</value></param>
<param><key>value</key><value>smtime</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>Smear time max (ms)</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0_0_1_0</value></param>
<param><key>value</key><value>wavsrate</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>label</key><value>WAV rate</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0_0_0_1_0_0_0</value></param>
<param><key>value</key><value>pulsar_pfb_helper.cur_sidereal(longitude+(0*wavsrate)).replace(",",":")</value></param>
<param><key>gui_hint</key><value>1,3,1,1</value></param>
<param><key>label</key><value>LMST</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>wavsrate</value></param>
<param><key>block_id</key><value>wav_rate</value></param>
<param><key>function_name</key><value>rate</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>amult</value></param>
<param><key>label</key><value>Audio level multipler for WAV log</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>pulsar_folded_vector</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>psize*sfold</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>nrfi</value></param>
<bus_sink>1</bus_sink>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>comment</key><value>Detector</value></param>
<param><key>vlen</key><value>nrfi</value></param>
</block>
<block>
<key>blocks_keep_one_in_n</key>
<param><key>id</key><value>blocks_keep_one_in_n_0</value></param>
<param><key>n</key><value>int(drate/2500)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>dcgain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>[0.0]*(psize*sfold)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>psize*sfold</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>amult</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_3</value></param>
<param><key>const</key><value>pulsar_pfb_helper.compute_rfi_map(rfilist, freq, samp_rate, 64)</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>nrfi</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_4</value></param>
<param><key>const</key><value>dcgain</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>psize*sfold</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>nrfi</value></param>
</block>
<block>
<key>blocks_vector_to_streams</key>
<param><key>id</key><value>blocks_vector_to_streams_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>nrfi</value></param>
<bus_source>1</bus_source>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>soundfile</value></param>
<param><key>samp_rate</key><value>2500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw</value></param>
<param><key>label</key><value>Bandwidth limit</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>99e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bypass</value></param>
<param><key>label</key><value>Bypass all dedispersion for WAV output</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_1</value></param>
<param><key>length</key><value>int(drate/20)</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dcgain</value></param>
<param><key>label</key><value>DC Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0e5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>decln</value></param>
<param><key>label</key><value>Declination</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>40.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>devid</value></param>
<param><key>label</key><value>Device ID</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>airspy=0,pack</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dm</value></param>
<param><key>label</key><value>Dispersion Measure</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>26.76</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dmult</value></param>
<param><key>label</key><value>Delay multiplier</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0,samp_rate,bwlim,samp_rate/10)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_2</value></param>
<param><key>comment</key><value>This FFT filter computes the dedispersion function
which is the inverse of the ISM transfer function.

Calls some helper code to compute the coefficients</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>nthreads</key><value>int(ldisp/32768)</value></param>
<param><key>taps</key><value>dispfilter</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>nrfi</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(nrfi)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frbfile</value></param>
<param><key>label</key><value>File for recording potential FRBs</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"/dev/null"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>611e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>longitude</value></param>
<param><key>label</key><value>Longitude of observer</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-76.03</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nfold</value></param>
<param><key>label</key><value>Number of foldings(approx)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>comment</key><value>The total-power/continuum auxillary data 
channel.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3</value></param>
<param><key>comment</key><value>Audio recording sub-graph

Take the band-limited (DC-600Hz or so) detector
output and send to a WAV file.</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_3_0</value></param>
<param><key>comment</key><value>Pulsar folding sub-graph

Take a nyquist-limited (at if_rate) signal, dc-block
and pass the result into a synchronous folder
and large-transient detector algorithm</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>comment</key><value>Folded profile display/logging subgraph</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate*0.8</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>1</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>args</key><value>devid</value></param>
<param><key>clock_source0</key><value>gpsdo</value></param>
<param><key>time_source0</key><value>gpsdo</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>if_rate/(samp_rate/nrfi)</value></param>
<param><key>atten</key><value>40</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prate</value></param>
<param><key>comment</key><value>Default is uncorrected rate for
PSR B0329+54</value></param>
<param><key>label</key><value>Pulse Rate(Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0/0.71452</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prefix</value></param>
<param><key>label</key><value>File Prefix</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"./psr-"</value></param>
</block>
<block>
<key>blocks_probe_signal_vx</key>
<param><key>id</key><value>profile_probe</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>psize*sfold</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psize</value></param>
<param><key>label</key><value>Points per pulse</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>epy_module</key>
<param><key>id</key><value>pulsar_pfb_helper</value></param>
<param><key>source_code</key><value># this module will be imported in the into your flowgraph
import sys
import os
import time
import ephem
import operator
import math
import xmlrpclib
import numpy

AUDIO_ON=1
AUDIO_OFF=0
audio_state=AUDIO_OFF

BASEBAND_ON=1
BASEBAND_OFF=0
baseband_state=BASEBAND_OFF

def compute_cmap (nchan):
    cmap=[]
    start = int(nchan)/2
    start += 1
    for i in range(0,nchan):
        cmap.append(start)
        start = start+1
        if (start &gt;= nchan):
            start = 0
    return cmap
        

def compute_rfi_map (flist, fc, bw, nchan):
    rmap=[1.0]*nchan
    incr = bw/nchan
    startf = fc-(bw/2.0)
    flist=flist.split(",")
    for i in range(0,nchan):
        for f in flist:
            if abs(startf-float(f)) &lt;= incr:
                rmap[i] = 0.0
    
    return (rmap)

    
def f_pad(filt,nc):
    f = list(filt)
    
    l = len(f)
    l = float(l)
    nl = math.ceil(l/float(nc))*nc
    nl = int(nl)
    nl = nl-int(l)
    low = int(nl/2)
    high = int(nl)-low
    return([0.0]*low+f+[0.0]*high)


def calculate_delays(dm,freq,bw,nchan,mult):

    f_lower = freq-(bw/2.0)
    f_upper = freq+(bw/2.0)
    
    f_lower /= 1.0e6
    f_upper /= 1.0e6
    
    f1 = 1.0/(f_lower*f_lower)
    f2 = 1.0/(f_upper*f_upper)

    #
    # Compute smear time
    #
    Dt = 4.15e3 * dm * (f2-f1)
    Dt = abs(Dt)
    Dt = Dt / nchan

    #
    # The number of samples at the input bandwidth that represent the total smear time
    #
    perchan = float(bw/nchan)*Dt
    
    
    delays=[]
    for d in range(0,nchan):
        z = float(d) * perchan
        z = round(z)
        z = int(z)
        delays.append(z*mult)
    
    #
    # invert delays
    #
    dl = len(delays)
    dl -= 1
    idelays = []
    for i in range(0,len(delays)):
        idelays.append(delays[(dl-i)])
    return (delays)

import  time
import sys
import os

def log(vec,pref,longitude,which,freq,bw,decln,st,en,xport):
    global audio_state
    global AUDIO_ON
    global AUDIO_OFF
    global baseband_state
    global BASEBAND_ON
    global BASEBAND_OFF
    
    ltp = time.gmtime()
    fn = pref + "-profile-%04d%02d%02d.csv" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    if (which == 1):
        fn = pref+"-tp-%04d%02d%02d.csv" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
    f = open(fn, "a")
    curs = cur_sidereal(longitude)
    stimes = curs.split(",")
    sidh = float(stimes[0])
    sidh += float(stimes[1])/60.0
    sidh += float(stimes[2])/3600.0
    
    logwindow = en - st
    logmid = st + (logwindow/2.0)
    
    #
    # 5 minutes for baseband data
    #
    bbst = logmid - (2.5 / 60.0)
    bben = logmid + (2.5 / 60.0)
    
        
    if (sidh &gt;= st and sidh &lt;= en and audio_state == AUDIO_OFF):
        try:
            s = xmlrpclib.Server('http://localhost:%d' % xport)
            sfn  = pref+"-demod-%04d%02d%02d.wav" % (ltp.tm_year, ltp.tm_mon, ltp.tm_mday)
            s.set_soundfile (sfn)
            audio_state = AUDIO_ON
        except:
            pass
        
    if (sidh &gt; en and audio_state == AUDIO_ON):
        try:
            s = xmlrpclib.Server('http://localhost:%d' % xport)
            s.set_soundfile("/dev/null")
            audio_state = AUDIO_OFF
        except:
            pass
            
    if which == 0:
        if (sidh &gt;= st and sidh &lt;= en):
            f.write("%02d,%02d,%02d,%s," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, curs))
            f.write("%9.4f,%f,%5.2f," % (freq/1.0e6, bw, decln))
            for val in vec:
                f.write("%.10f," % val)
            f.write("\n")
    else:
        f.write("%02d,%02d,%02d,%s," % (ltp.tm_hour, ltp.tm_min, ltp.tm_sec, curs))
        f.write("%9.4f,%f,%5.2f," % (freq/1.0e6, bw, decln))
        f.write("%.10f" % vec)
        f.write("\n")
    f.close()
    return 0

def cur_sidereal(longitude):
    longstr = "%02d" % int(longitude)
    longstr = longstr + ":"
    longitude = abs(longitude)
    frac = longitude - int(longitude)
    frac *= 60
    mins = int(frac)
    longstr += "%02d" % mins
    longstr += ":00"
    x = ephem.Observer()
    x.date = ephem.now()
    x.long = longstr
    jdate = ephem.julian_date(x)
    tokens=str(x.sidereal_time()).split(":")
    hours=int(tokens[0])
    minutes=int(tokens[1])
    seconds=int(float(tokens[2]))
    sidt = "%02d,%02d,%02d" % (hours, minutes, seconds)
    return (sidt)


def smear_time(dm,bw,freq):
    f_lower = freq-(bw/2.0)
    f_upper = freq+(bw/2.0)
    
    f_lower /= 1.0e6
    f_upper /= 1.0e6
    
    f1 = 1.0/(f_lower*f_lower)
    f2 = 1.0/(f_upper*f_upper)

    #
    # Compute smear time
    #
    Dt = 4.15e3 * dm * (f2-f1)
    Dt = abs(Dt)
    
    return (Dt)

#
# Compute a de-dispersion filter
#  From Hankins, et al, 1975
#
# This code translated from dedisp_filter.c from Swinburne
#   pulsar software repository
#
def compute_dispfilter(dm,doppler,bw,centerfreq):
    npts = compute_disp_ntaps(dm,bw,centerfreq)
    tmp = numpy.zeros(npts, dtype=numpy.complex)
    M_PI = 3.14159265358
    DM = dm/2.41e-10
    #
    # Because astronomers are a crazy bunch, the "standard" calculation
    #   is in Mhz, rather than Hz
    #
    centerfreq = centerfreq / 1.0e6
    bw = bw / 1.0e6
    
    isign = int(bw / abs (bw))
    
    # Center frequency may be doppler shifted
    cfreq     = centerfreq / doppler

    # As well as the bandwidth..
    bandwidth = bw / doppler

    # Bandwidth divided among bins
    binwidth  = bandwidth / npts

    # Delay is an "extra" parameter, in usecs, and largely
    #  untested in the Swinburne code.
    delay = 0.0
    
    # This determines the coefficient of the frequency response curve
    # Linear in DM, but quadratic in center frequency
    coeff = -isign * 2.0*M_PI * DM / (cfreq*cfreq)
    
    # DC to nyquist/2
    n = 0
    for i in range(int(npts/2),npts):
        freq = (n + 0.5) * binwidth
        phi = coeff*freq*freq/(cfreq+freq) + (2.0*M_PI*freq*delay)
        tmp[i] = complex(math.cos(phi), math.sin(phi))
        n += 1

    # -nyquist/2 to DC
    n = int(npts/2)
    n *= -1
    for i in range(0,int(npts/2)):
        freq = (n + 0.5) * binwidth
        phi = coeff*freq*freq/(cfreq+freq) + (2.0*M_PI*freq*delay)
        tmp[i] = complex(math.cos(phi), math.sin(phi))
        n += 1
    
    
    return(numpy.fft.ifft(tmp))

#
# Compute minimum number of taps required in de-dispersion FFT filter
#
def compute_disp_ntaps(dm,bw,freq):
    NTLIMIT=65536*2
    #
    # Dt calculations are in Mhz, rather than Hz
    #    crazy astronomers....
    mbw = bw/1.0e6
    mfreq = freq/1.0e6

    f_lower = mfreq-(mbw/2)
    f_upper = mfreq+(mbw/2)

    # Compute smear time
    Dt = dm/2.41e-4 * (1.0/(f_lower*f_lower)-1.0/(f_upper*f_upper))

    # ntaps is now bandwidth*smeartime
    ntaps = bw*Dt
    if (ntaps &lt; 32):
        ntaps = 32
    # special "flag" from command-line invoker to get around a bug
    #   in Gnu Radio involving the FFT filter implementation
    #   we can *never* increase the size of an FFT filter at runtime
    #   but can decrease it.  So there's a special "startup" flag (dm=1500.0)
    #   that causes us to return the NTLIMIT number of taps
    #
    if (dm &gt;= 1500.0):
        ntaps = NTLIMIT
    if (ntaps &gt; NTLIMIT):
        ntaps = NTLIMIT
    ntaps = int(math.log(ntaps) / math.log(2))
    ntaps = int(math.pow(2,ntaps+1))
    return(int(ntaps))
</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>pulsar_sink</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr
import os
import time


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, prate=1.3995, srate=2500, nfold=10, vlen=256):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Pulsar Folder Sink',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=[]
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.prate = prate
        self.srate = srate
        self.nfold = nfold
        self.vlen = vlen

        self.current_vlen = 0
        self.Dt = 1.0/float(srate)
        self.blen = (1.0/prate)/float(vlen)
        self.cbin = 0
        self.btime = 0.0
        self.ovect = [0.0]*vlen
        self.alpha = 1.0/float(float(self.nfold)*(float(self.srate)/float(self.vlen)))
        self.beta = 1.0 - self.alpha
        
        self.inlen = 0
        self.tdiff = 0.0


    def work(self, input_items, output_items):
        
        self.inlen = len(input_items[0])
        st = time.time()
        for x in input_items[0]:
            self.ovect[self.cbin] = ((self.alpha*x) + (self.beta*self.ovect[self.cbin]))
            self.btime += self.Dt
            if self.btime &gt;= self.blen:
                self.cbin += 1
                self.cbin = self.cbin % self.vlen
                self.btime = (self.btime-self.blen)
        
        en = time.time()
        
        self.tdiff = en-st
        return self.inlen


    def get_ovect(self):
        if (len(self.ovect) != self.vlen):
            print "Vector length bad %d" % len(self.ovect)
            raise ValueError("Returning vector of improper length in pulsar folder")
        return self.ovect

    def get_stats(self):
		return (self.inlen, self.tdiff)
</value></param>
<param><key>nfold</key><value>10</value></param>
<param><key>prate</key><value>prate/sfold</value></param>
<param><key>srate</key><value>drate</value></param>
<param><key>vlen</key><value>psize*sfold</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>average</key><value>0.1</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>the_freq</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>Sky Frequency Spectrum</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>Rel. Power (dBFS)</value></param>
<param><key>units</key><value>dBFS</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>2,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>name</key><value>tit</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>update_time</key><value>0.1</value></param>
<param><key>vlen</key><value>psize*sfold</value></param>
<param><key>x_axis_label</key><value>"Time (ms)"</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>((1.0/prate)/psize)*1000</value></param>
<param><key>x_units</key><value>"ms"</value></param>
<param><key>ymax</key><value>2.0</value></param>
<param><key>ymin</key><value>-0.25</value></param>
<param><key>y_axis_label</key><value>"Pulse brightness"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rfilist</value></param>
<param><key>label</key><value>RFI List</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>9e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sfold</value></param>
<param><key>comment</key><value>1 or 2 is typical</value></param>
<param><key>label</key><value>Sub-folding multiplier</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>1.0/(drate/400)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_1</value></param>
<param><key>alpha</key><value>1.0/2.2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_2</value></param>
<param><key>alpha</key><value>1.0/(if_rate/1.5)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_3</value></param>
<param><key>alpha</key><value>1.0/((samp_rate/64)/(if_rate/4))</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>nrfi</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>skyfreq</value></param>
<param><key>label</key><value>Sky Frequency</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>-1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>srate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tend</value></param>
<param><key>label</key><value>Profile logging end time</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>4.0</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>tp_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tstart</value></param>
<param><key>label</key><value>Profile logging start time</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>dedispersed</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>resampled_detector</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>stream_id</key><value>raw_baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>dedispersed</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>dedispersed</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_5</value></param>
<param><key>stream_id</key><value>resampled_detector</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_7</value></param>
<param><key>stream_id</key><value>raw_baseband</value></param>
</block>
<block>
<key>blocks_probe_rate</key>
<param><key>id</key><value>wav_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>mintime</key><value>1000</value></param>
<param><key>alpha</key><value>0.1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>xmlport</value></param>
<param><key>label</key><value>XML RPC Port number</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10009</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>localhost</value></param>
<param><key>port</key><value>xmlport</value></param>
</block>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>profile_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_one_in_n_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>wav_rate</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_3</source_block_id><sink_block_id>blocks_vector_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_4</source_block_id><sink_block_id>tp_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_1</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>64</source_key><sink_key>64</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>10</source_key><sink_key>10</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>11</source_key><sink_key>11</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>12</source_key><sink_key>12</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>13</source_key><sink_key>13</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>14</source_key><sink_key>14</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>15</source_key><sink_key>15</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>16</source_key><sink_key>16</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>17</source_key><sink_key>17</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>18</source_key><sink_key>18</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>19</source_key><sink_key>19</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>20</source_key><sink_key>20</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>21</source_key><sink_key>21</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>22</source_key><sink_key>22</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>23</source_key><sink_key>23</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>24</source_key><sink_key>24</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>25</source_key><sink_key>25</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>26</source_key><sink_key>26</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>27</source_key><sink_key>27</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>28</source_key><sink_key>28</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>29</source_key><sink_key>29</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>30</source_key><sink_key>30</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>31</source_key><sink_key>31</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>32</source_key><sink_key>32</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>33</source_key><sink_key>33</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>34</source_key><sink_key>34</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>35</source_key><sink_key>35</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>36</source_key><sink_key>36</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>37</source_key><sink_key>37</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>38</source_key><sink_key>38</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>39</source_key><sink_key>39</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>4</source_key><sink_key>4</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>40</source_key><sink_key>40</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>41</source_key><sink_key>41</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>42</source_key><sink_key>42</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>43</source_key><sink_key>43</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>44</source_key><sink_key>44</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>45</source_key><sink_key>45</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>46</source_key><sink_key>46</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>47</source_key><sink_key>47</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>48</source_key><sink_key>48</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>49</source_key><sink_key>49</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>5</source_key><sink_key>5</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>50</source_key><sink_key>50</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>51</source_key><sink_key>51</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>52</source_key><sink_key>52</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>53</source_key><sink_key>53</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>54</source_key><sink_key>54</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>55</source_key><sink_key>55</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>56</source_key><sink_key>56</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>57</source_key><sink_key>57</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>58</source_key><sink_key>58</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>59</source_key><sink_key>59</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>6</source_key><sink_key>6</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>60</source_key><sink_key>60</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>61</source_key><sink_key>61</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>62</source_key><sink_key>62</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>63</source_key><sink_key>63</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>7</source_key><sink_key>7</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>8</source_key><sink_key>8</sink_key></connection>
<connection><source_block_id>blocks_vector_to_streams_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>9</source_key><sink_key>9</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_2</source_block_id><sink_block_id>blocks_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>blocks_keep_one_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_1</source_block_id><sink_block_id>pulsar_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_2</source_block_id><sink_block_id>blocks_multiply_const_vxx_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_3</source_block_id><sink_block_id>blocks_multiply_const_vxx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>single_pole_iir_filter_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>dc_blocker_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_5</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_7</source_block_id><sink_block_id>fft_filter_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
